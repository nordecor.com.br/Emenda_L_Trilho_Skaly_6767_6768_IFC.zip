Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-04-02T16:33:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 02 16:33:10 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\b166bf9b-c17b-4d3c-89f2-3f626787a815\9a396e4a-bb73-483e-b497-7bb804f34e2d\ifc * Database version: 5507 * Database creation date: Wed Apr 02 16:33:09 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 02 16:33:10 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 02 16:33:10 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6768, Emenda_L_Trilho_Skaly_6767_6768_Nordecor:6768:328256
In: Nível 1
Type - Material: Metal - Alumínio - Preto
Type - Cotas - Comprimento 01: 117.5 mm; Comprimento 02: 117.4 mm
Type - Dados - Data de atualização: 31/03/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Emenda “L” de embutir para trilho SKALY acabamento branco; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6768; Nome do tipo: 6768; Número OmniClass: 23.80.70.11; Tipo de imagem: Imagem raster: 6768.png; Título OmniClass: Luminaries for Internal Lighting; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/emenda-l-de-embutir-p-trilho-skaly/
Type - Gráficos - Simbologia: Imagem raster: 6768 2D.png
Type - Materiais e acabamentos - Emenda "I": Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Emenda_L_Trilho_Skaly_6767_6768_Nordecor; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Cotas - Área: 0.00832095 m2; Volume: 0.0000301978 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Emenda_L_Trilho_Skaly_6767_6768_Nordecor: 6768; Família e tipo: Emenda_L_Trilho_Skaly_6767_6768_Nordecor: 6768; ID de tipo: Emenda_L_Trilho_Skaly_6767_6768_Nordecor: 6768; Tipo: Emenda_L_Trilho_Skaly_6767_6768_Nordecor: 6768
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
